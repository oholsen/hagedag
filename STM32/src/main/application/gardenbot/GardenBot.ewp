# IAR project GardenBot.ewp, settings and files
configuration StickF103 (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TODO_NDEBUG; STICKF103; STM32F100; STM32F103xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..; C:\Source\STM32\STM32Cube_FW_F1_V1.6.0\Drivers\STM32F1xx_HAL_Driver\Inc; C:\Source\STM32\STM32Cube_FW_F1_V1.6.0\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GardenBot.hex
  ILINK.IlinkOutputFile: gardenbot.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application/gardenbot
    ./: config.h main.c power_speed_test.txt
  group board
    ../../board/: board.h led.c led.h StickF103.h
  group hal
    ../../hal/: adc.c adc.h delay.c delay.h gpio.h halt.c pwm.c pwm.h startup_stm32f103xb.s systick.h usart.c usart.h usart_rx.c usart_rx.h
  group lib
    ../lib/: motorcontrol.c motorcontrol.h pidcontrol.c pidcontrol.h
